# IAR project Project.ewp, settings and files
configuration nrf52810_xxaa (ARM)
  General.OGChipSelectEditMenu: nRF52810_xxaa nRF52810_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52810_XXAA; NRF52_PAN_74
  ICCARM.CCIncludePath2: ..\nRF5_SDK\components; ..\nRF5_SDK\components\boards; ..\nRF5_SDK\components\drivers_nrf\nrf_soc_nosd; ..\nRF5_SDK\components\libraries\atomic; ..\nRF5_SDK\components\libraries\balloc; ..\nRF5_SDK\components\libraries\bsp; ..\nRF5_SDK\components\libraries\delay; ..\nRF5_SDK\components\libraries\experimental_section_vars; ..\nRF5_SDK\components\libraries\fifo; ..\nRF5_SDK\components\libraries\log; ..\nRF5_SDK\components\libraries\log\src; ..\nRF5_SDK\components\libraries\memobj; ..\nRF5_SDK\components\libraries\ringbuf; ..\nRF5_SDK\components\libraries\strerror; ..\nRF5_SDK\components\libraries\uart; ..\nRF5_SDK\components\libraries\util; ..\nRF5_SDK\components\toolchain\cmsis\include; ..; ..\nRF5_SDK\external\fprintf; ..\nRF5_SDK\integration\nrfx; ..\nRF5_SDK\integration\nrfx\legacy; ..\nRF5_SDK\modules\nrfx; ..\nRF5_SDK\modules\nrfx\drivers\include; ..\nRF5_SDK\modules\nrfx\hal; ..\nRF5_SDK\modules\nrfx\mdk; ..\nRF5_SDK\modules\nrfx\drivers\include; ..\nRF5_SDK\modules\nrfx\hal; ..\nRF5_SDK\integration\nrfx\legacy; ..\nRF5_SDK\modules\nrfx\mdk; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: uart_pca10040e.hex
  ILINK.IlinkOutputFile: uart_pca10040e.out
  ILINK.IlinkIcfFile: iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: main.c sdk_config.h
  group Application/src
    ../src/: 1wire.c 1wire.h an_read.c an_write.c analog.h config.c delay.c delay.h ds1990.c f10x-pcd8544.c f10x-pcd8544.h font6x8.h lcd.c lcd.h p18f14k50.h rfid.c rfid.h rfid_rx.c rfid_tx.c rfid_tx.h rw1990.c rw1990.h tm1990.c user.c utils.c utils.h
  group Board Definition
    ../nRF5_SDK/components/boards/: boards.c
  group None
    ../nRF5_SDK/modules/nrfx/mdk/: iar_startup_nrf52810.s system_nrf52810.c
  group nRF_Drivers
    ../nRF5_SDK/integration/nrfx/legacy/: nrf_drv_uart.c
    ../nRF5_SDK/modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_pwm.c nrfx_timer.c nrfx_uarte.c
    ../nRF5_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../nRF5_SDK/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../nRF5_SDK/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF5_SDK/components/libraries/atomic/: nrf_atomic.c
    ../nRF5_SDK/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK/components/libraries/memobj/: nrf_memobj.c
    ../nRF5_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../nRF5_SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../nRF5_SDK/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
